<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\DMA_SRAMtoSRAM_Half_Full.ewp</path>
	</project>
	<batchBuild />
</workspace>
