<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\FSMC_Ex8080TFT-LCD.ewp</path>
	</project>
	<batchBuild />
</workspace>
