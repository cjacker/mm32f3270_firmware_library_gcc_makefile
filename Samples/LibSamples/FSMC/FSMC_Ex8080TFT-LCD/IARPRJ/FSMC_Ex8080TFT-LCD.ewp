# IAR project FSMC_Ex8080TFT-LCD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F3277G9P MindMotion MM32F3277G9P
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: MM32F3277G9P; USE_IAR; _DLIB_FILE_DESCRIPTOR; __ALIGNED; ENABLEIP_ADC; ENABLEIP_BKP; ENABLEIP_CAN; ENABLEIP_COMP; ENABLEIP_DMA; ENABLEIP_RTC; ENABLEIP_USB_DEVICE; __MM3U1
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\Device\CMSIS\IAR_Core; ..\HARDWARE\FSMC_Ex8080TFTLCD; ..\HARDWARE\LED; ..\SYSTEM\DELAY; ..\SYSTEM\SYS; ..\SYSTEM\UART; ..\USER; ..\..\..\..\..\Device\MM32F327x\Include; ..\..\..\..\..\Device\MM32F327x\HAL_Lib\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __MM3U1
  ILINK.IlinkOutputFile: ADC_Awdg.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HALlib
    ../../../../../Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group HARDWARE
    ../HARDWARE/FSMC_Ex8080TFTLCD/: lcd.c lcddemo.c
    ../HARDWARE/LED/: led.c
  group STARTUP
    ../../../../../Device/MM32F327x/Source/IAR_StartAsm/: startup_mm32f327x_iar.s
    ../../../../../Device/MM32F327x/Source/: system_mm32f327x.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
