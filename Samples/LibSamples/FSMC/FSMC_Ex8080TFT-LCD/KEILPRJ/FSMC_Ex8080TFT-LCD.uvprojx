# Keil uVision project FSMC_Ex8080TFT-LCD.uvprojx, settings and files
target MM32Series (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F3277G9P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.5
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ENABLEFSMC USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\MM32F327x\Include;..\..\..\..\..\Device\MM32F327x\HAL_Lib\Inc;..\..\..\..\..\Device\CMSIS\KEIL_Core;..\USER;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\LED;..\HARDWARE\FSMC_Ex8080TFTLCD
  asm define: __MM3U1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../../../../Device/MM32F327x/Source/KEIL_StartAsm/: startup_mm32f327x_keil.s
    ../../../../../Device/MM32F327x/Source/: system_mm32f327x.c
  group HARDWARE
    ../HARDWARE/FSMC_Ex8080TFTLCD/: lcd.c lcddemo.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
  group HAL_Lib
    ../../../../../Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
