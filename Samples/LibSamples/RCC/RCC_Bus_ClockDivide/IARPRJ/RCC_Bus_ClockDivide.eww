<?xml version='1.0' encoding='utf-8'?>
<workspace>
	<project>
		<path>$WS_DIR$\RCC_Bus_ClockDivide.ewp</path>
	</project>
	<batchBuild />
</workspace>
